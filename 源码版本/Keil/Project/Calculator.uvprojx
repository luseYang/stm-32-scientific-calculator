# Keil uVision project Calculator.uvprojx, settings and files
target Calculator (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C6 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IRAM(0x20000000,0x2800) IROM(0x08000000,0x8000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Calculator +hex
  c flags: OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F10X_LD,USE_STDPERIPH_DRIVER
  c include: ..\Core;..\Hardware\Bit_Band;..\Hardware\Delay\Systick_Delay;..\Lib\inc;..\System;..\Project;..\Hardware\KEY;..\Hardware\LCD1602;..\Hardware\Calculator
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x2800
  group Core
    ../Core/: core_cm3.c startup_stm32f10x_ld.s
  group Lib
    ../Lib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group Project
    ./: main.c
  group Hardware
    ../Hardware/Delay/Systick_Delay/: systick_delay.c
    ../Hardware/KEY/: key.c
    ../Hardware/LCD1602/: lcd1602.c
    ../Hardware/Calculator/: Calculator.c
  group System
    ../System/: stm32f10x_it.c system_stm32f10x.c
